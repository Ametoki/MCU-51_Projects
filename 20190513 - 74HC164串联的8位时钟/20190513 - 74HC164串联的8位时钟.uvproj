# Keil uVision project 20190513 - 74HC164串联的8位时钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 20190513 - 74HC164串联的8位时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 20190513 - 74HC164串联的8位时钟.c
