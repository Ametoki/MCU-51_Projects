# Keil uVision project 20190526 - 频率测量2.0实物工程.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 20190526 - 频率测量2.0实物工程 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 频率测量V2.0 - LCD+分频器.c
