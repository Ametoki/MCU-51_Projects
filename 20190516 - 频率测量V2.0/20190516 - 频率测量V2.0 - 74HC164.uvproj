# Keil uVision project 20190516 - 频率测量V2.0 - 74HC164.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 20190516 - 频率测量V2.0 - 74HC164 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 频率测量V2.0 -164+分频器.c
